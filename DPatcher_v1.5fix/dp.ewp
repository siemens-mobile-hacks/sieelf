# IAR project dp.ewp, settings and files
configuration SGold (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NewSGold (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
configuration NewSGold E/EL71 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  group (top)
    ./: main.c
  group api
    api/: high_api.c irq_handler.asm low_api.c low_api_add.asm
  group flash
    flash/: bcclear.c cfi_flash.c uni_patch.c v_patch.c
  group fwork
    fwork/: fprintf.c fwork.c
  group gui
    gui/: fileman.c log.c lprintf.c menu.c rect_patcher.c uni.c
  group parser
    parser/: vkp_parser.c
  group virtual
    virtual/: virtual.c
