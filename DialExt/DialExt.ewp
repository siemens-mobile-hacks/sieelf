# IAR project DialExt.ewp, settings and files
configuration E71Cv41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; E71Cv41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S7Cv47
configuration SGold (ARM)
  as the first configuration, except:
  group (top)
    ./: conf_loader.c config.c func.asm main.c main_DaiKangroo_CG2.c
