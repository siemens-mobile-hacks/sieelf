# IAR project gb2ws.ewp, settings and files
configuration SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: mk_SGOLD.bat SK6Cv50
  XLINK.XclFile: SGOLD.xcl
configuration NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: mk_NEWSGOLD.bat E71Cv41
  XLINK.XclFile: NEWSGOLD.xcl
  group (top)
    ./: arm_swi.asm code.c
