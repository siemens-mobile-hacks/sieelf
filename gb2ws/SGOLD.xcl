-carm
-Z(CODE)CODE=A0FE0000-FFFFFFFF
-Z(CODE)SWILIB_GB2WS=A0FD4908-FFFFFFFF
-Z(CODE)SWILIB_WS2GB=A0FD490C-FFFFFFFF
