-carm
-Z(CODE)CODE=A1568000-FFFFFFFF
-Z(CODE)SWILIB_GB2WS=A0074908-FFFFFFFF
-Z(CODE)SWILIB_WS2GB=A007490C-FFFFFFFF
