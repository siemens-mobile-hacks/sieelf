# IAR project BalletMini.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  group (top)
    ./: additems.c conf_loader.c config_data.c destructors.c display_utils.c file_works.c func.asm history.c inet.c main.c mainmenu.c parse_oms.c readimg.c string_works.c ToDo.txt urlstack.c view.h
  group jpeglib
    jpeglib/: jinclude.h jpeglib.r79
