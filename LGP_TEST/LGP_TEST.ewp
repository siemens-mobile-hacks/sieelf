# IAR project LGP_TEST.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  AARM.ADefines: NEWSGOLD
  group (top)
    ./: func.asm main.c
