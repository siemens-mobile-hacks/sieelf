# IAR project SmartAlertsC.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  AARM.ADefines: NEWSGOLD
configuration Release_X75 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: X75
  group (top)
    ./: conf_loader.c config_data_c.c func.asm main.c SmartAlerts.h
