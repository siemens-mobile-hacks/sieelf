# IAR project TED.EWP, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  XLINK.XclFile: ..\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
configuration SG (ARM)
  as the first configuration, except:
  XLINK.XclFile: ..\TED\test.xcl
  XLINK.XExtraOptions: -ynpraw
  group (top)
    ./: COMMAND.C FIND.H FUNCTION.H
    ../: Swi.asm SWILIB.C SWILIB.H
