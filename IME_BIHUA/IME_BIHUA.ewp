# IAR project IME_BIHUA.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: E71Csw41
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ E71C
  XLINK.XclFile: E71Csw41.xcl
  group (top)
    ./: addr.h main.asm
