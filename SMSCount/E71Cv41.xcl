-carm
-Z(CODE)CODE,DATA_C=A1359680-FFFFFFFF

-Z(CODE)SMSHook=A0BF587C-FFFFFFFF
-Z(CODE)hookwindow=A05D87E4-FFFFFFFF
-Z(CODE)HookShow=A0860BB4-FFFFFFFF
