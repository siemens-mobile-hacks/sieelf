# IAR project SMSCount.ewp, settings and files
configuration E71Cv41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71Cv41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: ELKA; E71Cv41
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Cv41.xcl
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S7Cv47
  AARM.ADefines: NEWSGOLD; S7Cv47
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: S7Cv47.xcl
configuration ELC1v41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  AARM.ADefines: ELKA; ELC1v41
  postbuild: smsc.bat ELC1v41
  XLINK.XclFile: ELC1v41.xcl
configuration SL7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; SL7Cv47
  postbuild: smsc.bat SL7Cv47
  XLINK.XclFile: SL7Cv47.xcl
configuration S68Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; S68Cv51
  postbuild: smsc.bat S68Cv51
  XLINK.XclFile: S68Cv51.xcl
configuration M81Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; M81Cv51
  postbuild: smsc.bat M81Cv51
  XLINK.XclFile: M81Cv51.xcl
  group (top)
    ./: additional.c main.asm run_elf.c
