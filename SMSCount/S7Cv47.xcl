-carm
-Z(CODE)CODE,DATA_C=A0085800-FFFFFFFF

-Z(CODE)SMSHook=A0F4D888-FFFFFFFF
-Z(CODE)hookwindow=A0305F44-FFFFFFFF
-Z(CODE)HookShow=A0459710-FFFFFFFF