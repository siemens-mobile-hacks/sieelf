# IAR project MP3.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    mp3dec/: assembly.h bitstream.c buffers.c dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c mp3tabs.c polyphase.c scalfact.c stproc.c subband.c trigtabs.c
    ./: div.r79 func.asm Main.c
