# IAR project ELFLoader.ewp, settings and files
configuration S68Cv51 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; S68C
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: Lg8\S68Cv51.xcl
configuration SK6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN; X75
  XLINK.XclFile: Lg8\SK6Cv50.xcl
configuration CX6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN; X75
  XLINK.XclFile: Lg8\CX6Cv50.xcl
configuration M6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN; X75
  XLINK.XclFile: Lg8\M6Cv50.xcl
configuration S6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\S6Cv53.xcl
configuration C7Cv22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\C7Cv22.xcl
configuration SL6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\SL6Cv50.xcl
configuration E71Cv41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: Lg8\E71Cv41.xcl
configuration SL7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; SL7C
  XLINK.XclFile: Lg8\SL7Cv47.xcl
configuration CX7Av25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\CX7Av25.xcl
configuration C6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\C6Cv53.xcl
configuration CX7Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\CX7Cv50.xcl
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  XLINK.XclFile: Lg8\S7Cv47.XCL
configuration M81Cv51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  XLINK.XclFile: Lg8\M81Cv51.XCL
configuration ELC1v41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: Lg8\ELC1v41.xcl
configuration M75Cv25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\M75Cv25.xcl
configuration C81Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  XLINK.XclFile: Lg8\C81Cv50.XCL
configuration C7Cv24 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: SGOLD_CN
  XLINK.XclFile: Lg8\C7Cv24.xcl
  group (top)
    ./: additional.c conf_loader.c config_data.c elfloader.cpp ESI.asm EXT2.asm FSWI.asm IMB.asm png.c
    Lg8/: rets_C6Cv53.asm rets_C7Cv22.asm rets_C7Cv24.asm rets_C81Cv50.asm rets_CX6Cv50.asm rets_CX7Av25.asm rets_CX7Cv50.asm rets_E71Cv41.asm rets_ELC1v41.asm rets_M6Cv50.asm rets_M75Cv25.asm rets_M81Cv51.asm rets_S68Cv51.asm rets_S6Cv53.asm rets_S7Cv47.asm rets_SK6Cv50.asm rets_SL6Cv50.asm rets_SL7Cv47.asm
