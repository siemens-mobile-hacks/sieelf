# IAR project SieHelpMan.ewp, settings and files
configuration Release_SGOLD (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: filecopy.bat SieHelpMan_SGOLD.elf \Data\ZBin\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  postbuild: filecopy.bat SieHelpMan_ELKA.elf \MMCard\ZBin\
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  postbuild: filecopy.bat SieHelpMan_NEWSGOLD.elf \MMC\ZBin\
  group (top)
    ./: conf_loader.c config_data.c func.asm main.C
