# IAR project MegaDial2.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Unable to find default state
  ICCARM.CCDefines: NDEBUG
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD
  AARM.ADefines: NEWSGOLD; ELKA
configuration Release_SGOLD_SK65 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SK65
  AARM.ADefines: SK65
configuration Release_SGOLD_X75 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; X75
  AARM.ADefines: X75
  group (top)
    ./: Codeshow.c conf_loader.c config_datac.c extern.h func.asm main.c MegaDial.h
