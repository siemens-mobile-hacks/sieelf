# IAR project MegaDialc.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: F:\SieELF\MegaDial\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: test.xcl
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NDEBUG
  XLINK.XclFile: test.xcl
configuration Release_ELKA (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  group (top)
    ./: Codeshow.c conf_loader.c config_datac.c extern.h func.asm main.c
