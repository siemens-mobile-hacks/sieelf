# IAR project MegaDial.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NDEBUG
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
configuration Release_SGOLD_SK65 (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8f.h
  ICCARM.CCDefines: NDEBUG; SK65
  group (top)
    ./: Codeshow.c conf_loader.c config_data.c extern.h func.asm main.c
