# IAR project IDLEHOOK.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl4tptinl8n.h
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkarm.xcl
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NEWSGOLD (ARM)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: "obexcopy.exe" Release_ELKA\Exe\MNUEdit_ELKA.elf \Data\MNUEdit_ELKA.elf
  XLINK.XclFile: D:\Pasha\elf\test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_X65 (ARM)
  as the first configuration, except:
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: D:\Pasha\elf\ARHIVES\RunShortcuts\CfgEdit\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c fileman.c main.c menu.c
