-carm
-Z(CODE)HOOK=A0996750-FFFFFFFF
-Z(CODE)CODE,DATA_C=A155F000-FFFFFFFF
