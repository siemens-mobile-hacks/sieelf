# IAR project SHNMSMSICWIN2.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA; NEW
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: E71Csw41.xcl
configuration S7Csw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; NEW
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: S7Csw47.xcl
configuration ELC1sw41 (ARM)
  as the first configuration, except:
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ ELC1v41
  XLINK.XclFile: ELC1sw41.xcl
configuration CX6Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX6Cv50
  XLINK.XclFile: CX6Csw50.xcl
configuration S6Csw53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S6Cv53
  XLINK.XclFile: S6Csw53.xcl
configuration CX7Av25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD_X75
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX7Av25
  XLINK.XclFile: CX7Asw25.xcl
configuration SL6Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SL6Csw50
  XLINK.XclFile: SL6Csw50.xcl
configuration M6Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ M6Cv50
  XLINK.XclFile: M6Csw50.xcl
configuration SK6Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SK6Cv50
  XLINK.XclFile: SK6Csw50.xcl
configuration C81Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; NEW
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ C81Cv50
  XLINK.XclFile: C81Csw50.xcl
configuration S68Csw51 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; NEW
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ S68Cv51
  XLINK.XclFile: S68Csw51.xcl
configuration SL7Csw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD; NEW
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ SL7Cv47
  XLINK.XclFile: SL7Csw47.xcl
configuration CX7Csw50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: SGOLD; CX7Csw50
  AARM.ADefines: CX7Csw50
  postbuild: mk.bat $PROJ_DIR$ $EXE_DIR$ CX7Cv50
  XLINK.XclFile: CX7Csw50.xcl
  group (top)
    ./: entry.asm findName.c
