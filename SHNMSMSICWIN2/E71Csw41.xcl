-carm
-Z(CODE)HOOK=A096510C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A135B900-FFFFFFFF
