-carm
-Z(CODE)HOOK=A033618C-FFFFFFFF
-Z(CODE)CODE,DATA_C=A0F44DE0-FFFFFFFF