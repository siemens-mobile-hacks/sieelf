# IAR project ELFLoader.ewp, settings and files
configuration S7Cv47 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG; NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: xcl\S7Cv47.XCL
configuration E71Cv41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; NEWSGOLD; ELKA
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ E71Cv41
  XLINK.XclFile: xcl\E71Cv41.xcl
configuration ELC1v41 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; ELKA; NEWSGOLD
  AARM.ADefines: NEWSGOLD; ELKA
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ ELC1v41
  XLINK.XclFile: xcl\ELC1v41.xcl
configuration M81Cv51 (ARM)
  as the first configuration, except:
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ M81Cv41
  XLINK.XclFile: xcl\M81Cv51.xcl
configuration C81Cv50 (ARM)
  as the first configuration, except:
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ C81Cv50
  XLINK.XclFile: xcl\C81Cv50.xcl
configuration S68Cv51 (ARM)
  as the first configuration, except:
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ S68Cv51
  XLINK.XclFile: xcl\S68Cv51.xcl
configuration SL7Cv47 (ARM)
  as the first configuration, except:
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ SL7Cv47
  XLINK.XclFile: xcl\SL7Cv47.xcl
configuration CX7Av25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ CX7Av23
  XLINK.XclFile: xcl\CX7Av25.xcl
configuration SK6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ SK6Cv50
  XLINK.XclFile: xcl\SK6Cv50.xcl
configuration M6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SGOLD_CN; X75
  AARM.ADefines: SGOLD_CN; X75
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ M6Cv50
  XLINK.XclFile: xcl\M6Cv50.xcl
configuration C7Cv22 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ C7Cv22
  XLINK.XclFile: xcl\C7Cv22.xcl
configuration C7Cv24 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ C7Cv24
  XLINK.XclFile: xcl\C7Cv24.xcl
configuration CX7Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ CX7Cv50
  XLINK.XclFile: xcl\CX7Cv50.xcl
configuration CX6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ CX6Cv50
  XLINK.XclFile: xcl\CX6Cv50.xcl
configuration C6Cv53 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ C6Cv53
  XLINK.XclFile: xcl\C6Cv53.xcl
configuration SL6Cv50 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ SL6Cv50
  XLINK.XclFile: xcl\SL6Cv50.xcl
configuration M75Cv25 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; X75; SGOLD_CN
  AARM.ADefines: SGOLD_CN
  postbuild: mk.cmd $PROJ_DIR$ $EXE_DIR$ M75Cv25
  XLINK.XclFile: xcl\M75Cv25.xcl
  group (top)
    ./: additional.c conf_loader.c config_data.c elfloader_helper.c ESI.asm EXT2.asm FSWI.asm IMB.asm png.c
    Lg8/: rets_C6Cv53.asm rets_C7Cv22.asm rets_C7Cv24.asm rets_C81Cv50.asm rets_CX6Cv50.asm rets_CX7Av25.asm rets_CX7Cv50.asm rets_E71Cv41.asm rets_ELC1v41.asm rets_M6Cv50.asm rets_M75Cv25.asm rets_M81Cv51.asm rets_S68Cv51.asm rets_S6Cv53.asm rets_S7Cv47.asm rets_SK6Cv50.asm rets_SL6Cv50.asm rets_SL7Cv47.asm
  group loader3
    loader3/: elf.h env.c env.h loadelf.c loader.c loader.h loadlib.c Mutex.c Mutex.h strchrnul.c
