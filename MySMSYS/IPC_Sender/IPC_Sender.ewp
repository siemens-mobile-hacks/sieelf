# IAR project IPC_Sender.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: dl-stnl0.r79
  XLINK.XclFile: lnk0t.xcl
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: tph.bat
  XLINK.XclFile: E:\SRC\SVN\SieELF\MySMSYS\test.xcl
  XLINK.XExtraOptions: -ynpra
  group (top)
    ../: func.asm
    ./: main.c
