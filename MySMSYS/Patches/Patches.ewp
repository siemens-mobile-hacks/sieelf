# IAR project Patches.ewp, settings and files
configuration E71Csw41 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; ELKA; E71Cv41
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA; E71Cv41
  postbuild: elf2vkp.bat
  XLINK.XclFile: E71Csw41.xcl
configuration S7Csw47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: S7Csw47.xcl
configuration ELC1sw41 (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD; ELKA; ELC1v41
  XLINK.XclFile: ELC1sw41.xcl
configuration E71sw45 (ARM)
  as the first configuration, except:
  AARM.ADefines: NEWSGOLD; ELKA; E71v45
  XLINK.XclFile: E71sw45.xcl
  group (top)
    ./: add-on.c entery.asm entry_elka.asm
