<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\IPC_Sender\IPC_Sender.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MySMSYS.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Patches\Patches.ewp</path>
  </project>
  <batchBuild/>
</workspace>


