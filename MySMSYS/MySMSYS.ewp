# IAR project MySMSYS.ewp, settings and files
configuration Release (ARM)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpainl8n.h
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; LANG_CN
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  postbuild: tph.cmd $EXE_DIR$\MySMSYS_nsg.elf
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: DEBUG; NEWSGOLD
  postbuild: tph.cmd $EXE_DIR$\MySMSYS_debug.elf
configuration Release_ELKA (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_CN
configuration Release_ELKA_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; ELKA; LANG_EN; NO_CS
configuration Release_NEWSGOLD_LG3_EN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; NEWSGOLD_LG3; LANG_EN; NO_CS
  group (top)
    ./: adrList.c CodeShow.c createMenu.c edGui.c func.asm guiIdMan.c language.c main.c NativeAddressbook.c newDatReader.c numList.c popGui.c sms_dat.c smsList.c string_works.c template.c
  group Config
    ./: conf_loader.c conf_loader.h config_data.c config_data.h
  group Header
    ./: adrList.h CodeShow.h createMenu.h edGui.h guiIdMan.h language.h MySMSYS_ipc.h NewDatReader.h numList.h popGui.h rect_patcher.h sms_dat.h smsList.h string_works.h template.h
