# IAR project (S)Exit_Fun.ewp, settings and files
configuration MultiSGold (ARM)
  General.OGChipSelectEditMenu: LPC2106 NXP LPC2106
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl5tpannl8n.h
  General.OGChipSelectEditMenu: default None
  group (top)
    ./: conf_loader.c config_data.c func.asm main.c sexitfuncs.asm
