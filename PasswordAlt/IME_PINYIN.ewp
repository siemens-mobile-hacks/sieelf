# IAR project IME_PINYIN.ewp, settings and files
configuration EL71sw45 (ARM)
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NEWSGOLD; EL71sw45
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; EL71sw45
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ EL71sw45
  XLINK.XclFile: EL71v45.xcl
configuration S7Cv47 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD; S7Cv47
  AARM.ADefines: NEWSGOLD; S7Cv47
  postbuild: 2vkp.bat $PROJ_DIR$ $EXE_DIR$ S7Cv47
  XLINK.XclFile: S7Cv47.xcl
  group (top)
    ./: main.asm
