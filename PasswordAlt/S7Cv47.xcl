-carm
-Z(CODE)DUMP=A152E390-FFFFFFFF
-Z(CODE)CODE=A152E450-FFFFFFFF
-Z(CODE)ENTRY1=A04701A8-FFFFFFFF
-Z(CODE)DUMP1=A152E330-FFFFFFFF
-Z(CODE)ENTRY2=A045BB10-FFFFFFFF
-Z(CODE)DUMP2=A152E338-FFFFFFFF