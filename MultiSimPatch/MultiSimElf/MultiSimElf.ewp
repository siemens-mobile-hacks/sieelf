# IAR project MultiSimElf.ewp, settings and files
configuration Release_ELKA (ARM)
  General.OGChipSelectEditMenu: LPC2106 Philips LPC2106
  ICCARM.CCDefines: NEWSGOLD; ELKA
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  AARM.ADefines: NEWSGOLD; ELKA
  XLINK.XclFile: test.xcl
  XLINK.XExtraOptions: -ynpra
configuration Release_NSG (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NEWSGOLD
  AARM.ADefines: NEWSGOLD
  XLINK.XclFile: test.xcl
configuration Release_SGOLD (ARM)
  as the first configuration, except:
  XLINK.XclFile: test.xcl
  group (top)
    ./: conf_loader.c conf_loader.h config_data.c func.asm main.c mainmenu.c setmenu.c
  group Headers
    ./: language.h mainmenu.h setmenu.h
